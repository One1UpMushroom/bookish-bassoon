* Source: Infineon IRLB8721PBF simulation model ("Infineon-IRLB8721PBF-SimulationModels-v01_00-EN.spi"),
* as published by Infineon; byte-identical copies found in six unrelated public repositories (sha256 d90fe28ac4e3...).
* Kept verbatim below. Used here for non-commercial simulation of a personal project.
.SUBCKT irlb8721pbf 1 2 3
**************************************
*      Model Generated by MODPEX     *
*Copyright(c) Symmetry Design Systems*
*         All Rights Reserved        *
*    UNPUBLISHED LICENSED SOFTWARE   *
*   Contains Proprietary Information *
*      Which is The Property of      *
*     SYMMETRY OR ITS LICENSORS      *
*Commercial Use or Resale Restricted *
*   by Symmetry License Agreement    *
**************************************
* Model generated on Jan 12, 21
* MODEL FORMAT: SPICE3
* Symmetry POWER MOS Model (Version 1.0)
* External Node Designations
* Node 1 -> Drain
* Node 2 -> Gate
* Node 3 -> Source
M1 9 7 8 8 MM L=100u W=100u
.MODEL MM NMOS LEVEL=1 IS=1e-32
+VTO=2.65155 LAMBDA=0 KP=66.1931
+CGSO=9.78031e-06 CGDO=3.25092e-08
RS 8 3 0.00422807
D1 3 1 MD
.MODEL MD D IS=1.95977e-07 RS=0.0026745 N=1.49633 BV=30
+IBV=0.00025 EG=1 XTI=1 TT=1e-07
+CJO=6.04054e-10 VJ=5 M=0.635509 FC=0.5
RDS 3 1 5e+07
RD 9 1 0.0001
RG 2 7 9.50234
D2 4 5 MD1
* Default values used in MD1:
*   RS=0 EG=1.11 XTI=3.0 TT=0
*   BV=infinite IBV=1mA
.MODEL MD1 D IS=1e-32 N=50
+CJO=1.85747e-10 VJ=3.98881 M=0.373992 FC=9.99972e-09
D3 0 5 MD2
* Default values used in MD2:
*   EG=1.11 XTI=3.0 TT=0 CJO=0
*   BV=infinite IBV=1mA
.MODEL MD2 D IS=1e-10 N=1 RS=2.62403e-06
RL 5 10 1
FI2 7 9 VFI2 -1
VFI2 4 0 0
EV16 10 0 9 7 1
CAP 11 10 8.11848e-10
FI1 7 9 VFI1 -1
VFI1 11 6 0
RCAP 6 10 1
D4 0 6 MD3
* Default values used in MD3:
*   EG=1.11 XTI=3.0 TT=0 CJO=0
*   RS=0 BV=infinite IBV=1mA
.MODEL MD3 D IS=1e-10 N=1
.ENDS irlb8721pbf
